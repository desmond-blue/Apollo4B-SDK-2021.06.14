# Keil uVision project mpu_mspi_ddr_octal_psram_example.uvprojx, settings and files
target mpu_mspi_ddr_octal_psram_example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.8
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: mpu_mspi_ddr_octal_psram_example
  AfterMake: fromelf --bin --output bin\mpu_mspi_ddr_octal_psram_example.bin bin\mpu_mspi_ddr_octal_psram_example.axf
  AfterMake: fromelf -cedrst --output bin\mpu_mspi_ddr_octal_psram_example.txt bin\mpu_mspi_ddr_octal_psram_example.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AM_PACKAGE_BGA AM_UTIL_FAULTISR_PRINT AM_DEBUG_PRINTF APS12808L AM_PART_APOLLO4B keil
  c include: ../../../../bsp;../src;../../../../../../mcu/apollo4b;../../../../../../CMSIS/AmbiqMicro/Include;../../../../../..;../../../../../../devices;../../../../../../utils;../../../../../../CMSIS/ARM/Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ../src/: am_resources.c regions.c mpu.c
  group devices
    ../../../../../../devices/: am_devices_mspi_psram_aps12808l.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c am_util_faultisr.c
  group keil
    ../keil/: startup_keil.s
  group lib
    ../../../../../../mcu/apollo4b/hal/mcu/keil/bin/: libam_hal.lib
    ../../../../bsp/keil/bin/: libam_bsp.lib
