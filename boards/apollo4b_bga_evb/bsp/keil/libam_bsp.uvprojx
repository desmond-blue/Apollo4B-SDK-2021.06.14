# Keil uVision project libam_bsp.uvprojx, settings and files
target libam_bsp (ARM-ADS)
  device: AMAP42KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.5
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: libam_bsp (library)
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NUM_LANES=1 DBI_WIDTH=AM_HAL_DSI_DBI_WIDTH_8 AM_PART_APOLLO4B B_USE_DPHYPLL=true AM_PACKAGE_BGA DSI_FREQ=AM_HAL_DSI_FREQ_TRIM_X12 DISP_TYPE=RM67162_DSI DISP_CFG keil
  c include: ../../../../CMSIS/ARM/Include;../../../../CMSIS/AmbiqMicro/Include;../../../../mcu/apollo4b;../../../../devices;../../../../utils
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  group source_files
    ../: am_bsp.c am_bsp_pins.c
